# Keil uVision project STM_FSMC_LCDk.uvproj, settings and files
target redScope_ADC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: redScope
  c flags: Optim=3
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\inc;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\Core\CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ./: startup_stm32f10x_hd.s
    ./Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Src
    ./src/: adc.c dma.c main_ADC.c stm32f10x_it.c fsmc_sram.c thermalRes10k.c
  group STM_Lib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LCD
    ./src/LCD/: ili9320_touch.c lcdProcess.c stm3210e_lcd.c
    ./src/: font8x16.c fonts16x24.c
